FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"
SRC_URI += "file://resolve_yocto_kernel_build_error.patch"
